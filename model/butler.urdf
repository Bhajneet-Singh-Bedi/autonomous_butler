Commit message: [Bhajneet] removed camera from butler_bot

File: model/butler.urdf (robot description, URDF)
Before this commit: robot butler_bot, 7 links, 6 joints
Links:
- removed link camera_frame
- removed link camera_link
Joints:
- removed joint camera_frame_joint
- removed joint camera_joint
